# Keil uVision project 07_OS_kernel.uvprojx, settings and files
target OS_kernel (6180000::V6.18::ARMCLANG)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 07_OS_kernel
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F1 STD_CON=USART2 MST_SIZE=0x400
  c misc: -Wno-cast-qual -Wno-missing-prototypes -Wno-unreachable-code-return -Wno-pointer-arith -Wno-missing-variable-declarations -Wno-padded -Wno-implicit-function-declaration -Wno-implicit-int-conversion -Wno-sign-conversion -Wno-self-assign -Wno-missing-noreturn -Wno-comment
  c include: .\src\kernel;.\src\ports\cortex-m;.\src\libopencm3\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group kernel
    ./src/kernel/: atomkernel.c atommutex.c atomqueue.c atomsem.c atomtimer.c
  group ports
    ./src/ports/cortex-m/: atomport.c atomport-asm.S
    ./src/ports/cortex-m/common/: helloworld.c stm32_con.c stubs.c
    ./src/ports/cortex-m/boards/nucleo-f103rb/: board_setup.c
  group libopencm3
    ./src/libopencm3/lib/cm3/: nvic.c systick.c vector.c assert.c
    ./src/libopencm3/lib/stm32/common/: gpio_common_all.c rcc_common_all.c usart_common_all.c usart_common_f124.c flash_common_all.c
    ./src/libopencm3/lib/dispatch/: vector_chipset.c vector_nvic.c
    ./src/libopencm3/lib/stm32/f1/: f1_vector_nvic.c f1_rcc.c f1_gpio.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
