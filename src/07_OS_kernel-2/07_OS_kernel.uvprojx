# Keil uVision project 07_OS_kernel.uvprojx, settings and files
target OS_kernel (6180000::V6.18::ARMCLANG)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 07_OS_kernel
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: -Wno-macro-redefined -Wno-unused-parameter -Wno-unused-variable -Wno-cast-qual -Wno-missing-prototypes -Wno-unreachable-code-return -Wno-pointer-arith -Wno-missing-variable-declarations -Wno-padded -Wno-implicit-function-declaration -Wno-implicit-int-conversion -Wno-sign-conversion -Wno-self-assign -Wno-missing-noreturn -Wno-comment
  c include: .\src\kernel;.\src\arch
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group kernel
    ./src/kernel/: atomkernel.c atommutex.c atomqueue.c atomsem.c atomtimer.c
  group samples
    ./: main.c
  group arch
    ./src/arch/: atomport.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
