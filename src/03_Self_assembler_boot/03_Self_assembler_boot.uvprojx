# Keil uVision project 03_Self_assembler_boot.uvprojx, settings and files
target Self_assembler_boot (6180000::V6.18::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: 03_Self_assembler_boot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group ASM
    ./: reset.asm stack.asm heap.asm startup.asm
  group C
    ./: main.c
software components: CMSIS:CORE 5.6.0
